# Keil uVision project BareMetal_LED_Blinky_TCM.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AE722F80F55D5AS:M55_HE Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.1.0.0-rc2
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x58000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ELITTLE
  output: BareMetal_LED_Blinky_TCM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x58000000 size 0x40000
  scatter file: .\RTE\Device\AE722F80F55D5AS_M55_HE\M55_HE.sct
  group Source Group 1
    ./: LED_blink_baremetal.c
software components: CMSIS-Compiler:I/O:STDOUT 1.0.0, CMSIS:CORE 5.6.0, Device:Retarget IO:STDOUT 1.0.0, Device:SOC Peripherals:GPIO 1.0.0, Device:SOC Peripherals:PINCONF 1.0.0, Device:SOC Peripherals:USART 1.0.0, Device:Startup 1.0.0
